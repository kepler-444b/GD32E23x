# Keil uVision project GD32E23x.uvprojx, settings and files
target GD32E23x (6240000::V6.24::ARMCLANG)
  device: GD32E235CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.3.2
  cpu: IRAM(0x20000000,0x0004000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E235
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\GD32E23x_standard_peripheral\Include;..\..\Firmware\CMSIS\GD\GD32E23x\Include;..\..\Source\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../: gd32e23x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Utilities
    ../../Utilities/: gd32e230c_eval.c
  group Doc
    ../: readme.txt
  group Device
    ../../Source/device/: device.c device.h devicemanager.h
    ../../Source/device/triac_driver/: triac_driver.c triac_driver.h
  group Common
    ../../Source/gpio/: gpio.c gpio.h
    ../../Source/eventbus/: eventbus.c eventbus.h
    ../../Source/flash/: flash.c flash.h
    ../../Source/watchdog/: watchdog.c watchdog.h
    ../../Source/zero/: zero.c zero.h
    ../../Source/timer/: timer.c timer.h
    ../../Source/usart/: usart.c usart.h
    ../../Source/protocol/: protocol.c protocol.h
    ../../Source/pcb/: pcb.c pcb.h
software components: CMSIS:CORE 6.1.1
